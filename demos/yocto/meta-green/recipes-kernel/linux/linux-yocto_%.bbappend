FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
SRC_URI += "file://green-power.cfg file://green-diagnostics.cfg"
